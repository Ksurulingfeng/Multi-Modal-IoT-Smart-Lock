# Keil uVision project smart_door_lock.uvprojx, settings and files
target smart_door_lock (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: smart_door_lock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Inc;../FreeRTOS/include;../FreeRTOS/portable/RVDS/ARM_CM3;../Middleware/Inc;../Tasks/Inc;../App/Inc;..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MDK-ARM
    ./: startup_stm32f103xb.s
  group Core
    ../Core/Src/: sys.c main.c init.c gpio.c tim.c iwdg.c usart.c spi.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/BSP
    ../Drivers/BSP/Src/: AS608.c Buzzer.c Keypad.c LED.c OLED_I2C.c RC522.c Servo.c AT24Cxx.c ESP8266.c
  group FreeRTOS/portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS/source
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware
    ../Middleware/Src/: debug.c display.c mqtt.c MyI2C.c MySPI.c
  group Tasks
    ../Tasks/Src/: doorLockControl_task.c finger_task.c IWDGRefresh_task.c keypad_task.c network_task.c NFC_task.c verify_task.c
  group Config
    ../Config/: config.h
  group APP
    ../App/Src/: doorLockControl.c manage.c network.c storage.c verify.c
software components: CMSIS:CORE 6.1.0
